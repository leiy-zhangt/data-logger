# Keil uVision project data logger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: data logger
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Basic\inc;..\HardWare\IIC;..\HardWare\SPI;..\HardWare\USART;..\HardWare\W25N;..\System\delay;..\System\sys;..\User;..\CMSIS;..\HardWare\BMI055;..\HardWare\LED;..\HardWare\SERVE;..\HardWare\BUZZER;..\HardWare\BMP388;..\HardWare\QMC5883L;..\HardWare\ATGM336H;..\HardWare\ADI16448
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Basic
    ../Basic/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group HardWare
    ../HardWare/IIC/: iic.c
    ../HardWare/USART/: usart.c
    ../HardWare/SPI/: spi.c
    ../HardWare/BMI055/: bmi055.c
    ../HardWare/LED/: led.c
    ../HardWare/W25N/: w25n.c
    ../HardWare/SERVE/: serve.c
    ../HardWare/BUZZER/: buzzer.c
    ../HardWare/BMP388/: bmp388.c
    ../HardWare/QMC5883L/: qmc5883l.c
    ../HardWare/ATGM336H/: atgm336h.c
    ../HardWare/ADI16448/: adi16448.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c command.c computation.c
